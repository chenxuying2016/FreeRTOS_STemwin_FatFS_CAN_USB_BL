# IAR project Project.ewp, settings and files
configuration Flash (ARM)
  General.OGChipSelectEditMenu: STM32F429BI ST STM32F429BI
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Full.h
  General.CoreVariant: 39
  General.FPU2: 4
  ICCARM.CCDefines: USE_STDPERIPH_DRIVER; STM32F429_439xx
  ICCARM.CCIncludePath2: ..\..\Libraries\CMSIS\Include; ..\..\Libraries\CMSIS\Device\ST\STM32F4xx\Include; ..\..\Libraries\STM32F4xx_StdPeriph_Driver\inc; ..\..\User\bsp\inc; ..\..\User\bsp; ..\..\User; ..\..\User\fonts; ..\..\emWin\Include; ..\..\emWin\emWinTask; ..\..\emWin\Config
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: Project.hex
  postbuild: CopyHex_Flash.bat
  ILINK.IlinkOutputFile: Project.out
  ILINK.IlinkIcfFile: stm32f4xx_flash.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group BSP
    ../../User/bsp/: bsp.c bsp.h stm32f4xx_assert.c stm32f4xx_it.c
    ../../User/bsp/src/: bsp_dwt.c bsp_eeprom_24xx.c bsp_ext_io.c bsp_fmc_sdram.c bsp_i2c_gpio.c bsp_key.c bsp_led.c bsp_sdio_sd.c bsp_tim_pwm.c bsp_timer.c bsp_uart_fifo.c
  group CMSIS
    ../../User/bsp/: system_stm32f4xx.c
  group Doc
    ../../Doc/: 01.例程功能说明.txt 02.例程修改记录.txt
  group EWARMv7
    ../../Libraries/CMSIS/Device/ST/STM32F4xx/Source/Templates/iar/: startup_stm32f429_439xx.s
  group Fonts
    ../../User/fonts/: asc12.c asc16.c fonts.h hz12.c hz16.c hz24.c hz32.c ra8875_asc_width.c
  group GUI/Config
    ../../emWin/Config/: GUIConf.c GUIConf.h LCDConf_Lin_Template.c LCDConf_Lin_Template.h
  group GUI/DEMO
    ../../emWin/emWinTask/: MainTask.c MainTask.h
  group GUI/Lib
    ../../emWin/GUILib/: STemWin532_CM4_IAR_ot.a
  group GUI_X
    ../../emWin/GUI_X/: GUI_X.c
  group LCD_Driver
    ../../User/bsp/src/: bsp_gt811.c bsp_tft_429.c bsp_tft_lcd.c bsp_touch.c bsp_ts_ft5x06.c param.c TOUCH_STMPE811.c
  group StdPeriph_Driver
    ../../Libraries/STM32F4xx_StdPeriph_Driver/src/: misc.c stm32f4xx_dma.c stm32f4xx_dma2d.c stm32f4xx_fmc.c stm32f4xx_gpio.c stm32f4xx_ltdc.c stm32f4xx_rcc.c stm32f4xx_sdio.c stm32f4xx_syscfg.c stm32f4xx_tim.c stm32f4xx_usart.c
  group User
    ../../User/: main.c
