# Keil uVision project project.uvproj, settings and files
target Flash (ARM-ADS)
  device: STM32F429BI STMicroelectronics
  cpu: IRAM(0x20000000-0x2002FFFF) IRAM2(0x10000000-0x1000FFFF) IROM(0x8000000-0x81FFFFF) CLOCK(25000000) CPUTYPE("Cortex-M4") FPU2
  output: output +hex
  AfterMake: CopyHex_Flash.bat
  c flags: Optim=1 OneElfS=1
  c define: USE_STDPERIPH_DRIVER,STM32F429_439xx,USE_USB_OTG_HS,USE_EMBEDDED_PHY
  c misc: --c99
  c include: ..\..\Libraries\CMSIS\Include;..\..\Libraries\CMSIS\Device\ST\STM32F4xx\Include;..\..\Libraries\STM32F4xx_StdPeriph_Driver\inc;..\..\User\bsp\inc;..\..\User\bsp;..\..\User;..\..\FreeRTOS\include;..\..\FreeRTOS\portable\RVDS\ARM_CM4F;..\..\User\fonts;..\..\emWin\GUI_X;..\..\emWin\Config;..\..\emWin\Include;..\..\emWin\emWinTask;..\..\User\fatfs\src;..\..\Libraries\STM32_USB_OTG_Driver\inc;..\..\Libraries\STM32_USB_HOST_Library\Core\inc;..\..\Libraries\STM32_USB_HOST_Library\Class\MSC\inc;..\..\User\usbh_mass_storage;..\..\User\app\inc
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x200000
  memory RVCT9: RAM 0x20000000 size 0x30000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group User
    ../../User/: main.c includes.h FreeRTOSConfig.h SysInfoTest.c can_network.c ARM_FPGA.c
    ../../User/app/src/: demo_fatfs.c
  group BSP
    ../../User/bsp/: bsp.c bsp.h stm32f4xx_it.c stm32f4xx_assert.c
    ../../User/bsp/src/: bsp_led.c bsp_key.c bsp_dwt.c bsp_ext_io.c bsp_uart_fifo.c bsp_tim_pwm.c bsp_i2c_gpio.c bsp_fmc_sdram.c bsp_eeprom_24xx.c bsp_sdio_sd.c bsp_beep.c bsp_spi_bus.c bsp_spi_flash.c
  group MDK-ARM
    ../../Libraries/CMSIS/Device/ST/STM32F4xx/Source/Templates/arm/: startup_stm32f429_439xx.s
  group StdPeriph_Driver
    ../../Libraries/STM32F4xx_StdPeriph_Driver/src/: misc.c stm32f4xx_gpio.c stm32f4xx_rcc.c stm32f4xx_fmc.c stm32f4xx_tim.c stm32f4xx_ltdc.c stm32f4xx_usart.c stm32f4xx_syscfg.c stm32f4xx_dma.c stm32f4xx_dma2d.c stm32f4xx_sdio.c stm32f4xx_can.c stm32f4xx_spi.c stm32f4xx_exti.c
  group CMSIS
    ../../User/bsp/: system_stm32f4xx.c
  group GUI_X
    ../../emWin/GUI_X/: GUI_X_FreeRTOS.c
  group GUI/Config
    ../../emWin/Config/: GUIConf.c GUIConf.h LCDConf_Lin_Template.c LCDConf_Lin_Template.h
  group GUI/DEMO
    ../../emWin/emWinTask/: MainTask.c MainTask.h
  group GUI/Lib
    ../../emWin/GUILib/: STemWin532_CM4_OS_Keil_ot.lib
  group Fonts
    ../../User/fonts/: asc12.c asc16.c hz16.c hz24.c hz32.c ra8875_asc_width.c yahei30.c yahei36.c kai24.c yahei72.c yahei48.c kai20.c
  group LCD_Driver
    ../../User/bsp/src/: param.c bsp_tft_lcd.c bsp_tft_429.c bsp_touch.c bsp_gt811.c bsp_ts_ft5x06.c TOUCH_STMPE811.c
  group FreeRTOS/Source
    ../../FreeRTOS/: croutine.c event_groups.c list.c queue.c tasks.c timers.c
  group FreeRTOS/Ports
    ../../FreeRTOS/portable/MemMang/: heap_4.c
    ../../FreeRTOS/portable/RVDS/ARM_CM4F/: port.c portmacro.h
  group FatFS
    ../../User/fatfs/src/: diskio.c diskio.h ff.c ff.h ffconf.h integer.h
    ../../User/fatfs/src/option/: cc936.c
  group USB_OTG_Driver
    ../../Libraries/STM32_USB_OTG_Driver/src/: usb_core.c usb_hcd.c usb_hcd_int.c
  group USB_Host_Library
    ../../Libraries/STM32_USB_HOST_Library/Core/src/: usbh_core.c usbh_hcs.c usbh_ioreq.c usbh_stdreq.c
    ../../Libraries/STM32_USB_HOST_Library/Class/MSC/src/: usbh_msc_bot.c usbh_msc_core.c usbh_msc_scsi.c
  group USBH MassStorage
    ../../User/usbh_mass_storage/: usb_bsp.c usbh_it.c usbh_usr.c usb_conf.h usbh_bsp_msc.h usbh_conf.h usbh_usr.h
  group Doc
    ../../Doc/: 01.例程功能说明.txt 02.例程修改记录.txt
